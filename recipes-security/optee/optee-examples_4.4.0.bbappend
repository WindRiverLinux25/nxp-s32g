require optee-nxp.inc

SRCREV:nxp-s32g = "378dc0db2d5dd279f58a3b6cb3f78ffd6b165035"
