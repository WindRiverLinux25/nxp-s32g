require ${@bb.utils.contains_any('MACHINE', 'nxp-s32g aptiv-cvc-131', 'linux-yocto-secure.inc', '', d)}
