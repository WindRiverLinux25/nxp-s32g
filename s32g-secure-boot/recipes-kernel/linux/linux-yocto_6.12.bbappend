require ${@bb.utils.contains('MACHINE', 'nxp-s32g', 'linux-yocto-secure.inc', '', d)}
